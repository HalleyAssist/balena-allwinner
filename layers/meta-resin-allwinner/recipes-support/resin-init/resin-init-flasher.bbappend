# Flash to internal eMMC - kernel always enumerates emmc as mmcblk1
INTERNAL_DEVICE_KERNEL_nanopi-neo-air = "mmcblk1"
